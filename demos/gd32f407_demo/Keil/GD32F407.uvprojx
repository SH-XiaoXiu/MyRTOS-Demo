# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32F407,DEBUG_PRINT=0
  c include: ..\config;..\src;..\platform\include;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Libraries;..\..\..\MyRTOS\include;..\..\..\MyRTOS\private;..\..\..\MyRTOS\kernel\include;..\..\..\MyRTOS\boot\include;..\..\..\MyRTOS\services\include;..\..\..\MyRTOS\programs\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Demo
    ../src/: main.c gd32f4xx_it.c
    ../config/: MyRTOS_Config.h gd32f4xx_libopt.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_dma.c gd32f4xx_usart.c gd32f4xx_adc.c gd32f4xx_timer.c gd32f4xx_exti.c gd32f4xx_syscfg.c
  group Lib
    ../Libraries/: lib_usart0.c
  group MyRTOS/Kernel
    ../../../MyRTOS/kernel/: myrtos_init.c myrtos_memory.c myrtos_scheduler.c myrtos_task.c myrtos_signal.c myrtos_queue.c myrtos_mutex.c myrtos_semaphore.c myrtos_tick.c myrtos_extension.c
  group MyRTOS/Services
    ../../../MyRTOS/services/: MyRTOS_AsyncIO.c MyRTOS_IO.c MyRTOS_Log.c MyRTOS_Monitor.c MyRTOS_Timer.c MyRTOS_Utils.c MyRTOS_VTS.c MyRTOS_Process.c
  group MyRTOS/Arch
    ../../../MyRTOS/arch/ARM_CM4/: ARM_CM4F.c
  group MyRTOS/Boot
    ../../../MyRTOS/boot/: MyRTOS_Boot.c
  group Platform
    ../platform/: platform_hw.c platform_console.c platform_timer.c platform_hooks.c platform_error_handler.c
  group MyRTOS/Programs
    ../../../MyRTOS/programs/: shell_core.c shell_process_main.c shell_builtin.c shell_monitor.c shell_log.c shell_process.c shell_platform.c shell_sysinfo.c init_main.c log_main.c shell_main.c
